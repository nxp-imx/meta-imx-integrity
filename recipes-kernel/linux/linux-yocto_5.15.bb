# BB file to remove .bbappend dependency

SUMMARY = "A recipe that does nothing"
LICENSE = "GPLv2"
SRC_URI = ""

