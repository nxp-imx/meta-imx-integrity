IMAGE_INSTALL:append =  " initramfs-creation"
